## base_external/package/aesd-char/Config.in
```kconfig
config BR2_PACKAGE_AESD_CHAR
    bool "aesd-char"
    help
        AESD char driver
```
